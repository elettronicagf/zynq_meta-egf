#Note: Mention Each package in individual line
#      cascaded representation with line breaks are not valid in this file.
IMAGE_INSTALL_append = " peekpoke"
IMAGE_INSTALL_append = " gpio-demo"
IMAGE_INSTALL_append = " i2csensor"
IMAGE_INSTALL_append = " dialog-control"
IMAGE_INSTALL_append = " get-gpio-offsets"
